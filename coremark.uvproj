# Keil uVision project coremark.uvproj, settings and files
target coremark (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: coremark +hex
  group source
    ./: main.c
  group usb
    ./usb/: stc.h usb.c usb.h usb_desc.c usb_desc.h usb_req_class.c usb_req_class.h usb_req_std.c usb_req_std.h usb_req_vendor.c usb_req_vendor.h util.c util.h uart.c uart.h
  group library
    ./library/: common.h delay.h stdbool.h stdint.h Type_def.h delay.c
  group coremark-1.01
    ./coremark-1.01/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c coremark.h core_portme.c core_portme.h
